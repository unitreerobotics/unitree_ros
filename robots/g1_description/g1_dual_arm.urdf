Commit message: modify URDF material to facilitate conversion to USD

File: robots/g1_description/g1_dual_arm.urdf (robot description, URDF)
Before this commit: robot g1_dual_arm, 26 links, 25 joints
Joints:
- joint imu_in_pelvis_joint: parent pelvis -> waist_yaw_link
