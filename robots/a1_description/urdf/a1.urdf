Commit message: Realistic collision box

File: robots/a1_description/urdf/a1.urdf (robot description, URDF)
Before this commit: robot a1_description, 23 links, 22 joints
Links:
- link trunk: geometry collision box size=0.267 0.08 0.114; collision cylinder length=0.267 radius=0.057
